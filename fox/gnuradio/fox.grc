options:
  parameters:
    generate_options: qt_gui
    id: foxv6
    output_language: python
    title: Fox v5
  states: {}

blocks:
- name: amp_on
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Amp On +14 dB
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: audio_freq
  id: variable_qtgui_range
  parameters:
    label: audio_freq
    start: '500'
    step: '50'
    stop: '2000'
    value: '1000'
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: cw_speed
  id: variable_qtgui_range
  parameters:
    label: cw_speed
    rangeType: int
    start: '25'
    step: '1'
    stop: '150'
    value: '50'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: freq
    start: 144e6
    step: 1e3
    stop: 145e6
    value: 144560e3
  states: {}
- name: power
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    label: Power
    'true': '1'
    type: real
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    label: VGA Gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '47'
    value: '40'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_2
  id: analog_const_source_x
  parameters:
    const: complex(power,0)
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: audio_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {bus_sink: true}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(samp_rate * 6 / cw_speed)
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: 1-power
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (1, 1, 1, 0, 1, 1, 1, 0, 0, 0, 1, 1 ,1 ,0, 1, 1, 1, 0, 1, 1, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0)
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: amp_on
    center_freq: freq
    dev_args: buffers=1
    samp_rate: samp_rate
    type: fc32
    vga: vga_gain
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_const_source_x_2, '0', blocks_multiply_xx_0_0_0, '1']
- [analog_sig_source_x_0, '0', blocks_float_to_complex_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_xx_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_xx_0_0_0, '0', blocks_selector_0, '0']
- [blocks_repeat_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_selector_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_selector_0, '1', blocks_null_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
